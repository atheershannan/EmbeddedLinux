## buildroot-package/mymod/Config.in
```kconfig
config BR2_PACKAGE_MYMOD
	bool "mymod"
	depends on BR2_LINUX_KERNEL
	help
	  Hello world kernel module from GitHub - Logtel exercise.
```
